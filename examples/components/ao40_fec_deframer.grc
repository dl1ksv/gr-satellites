options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: ao40_fec_deframer
    output_language: python
    run_options: run
    title: AO-40 FEC deframer component example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:1,0
    samp_rate: samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: satellites_ao40_fec_deframer_0
  id: satellites_ao40_fec_deframer
  parameters:
    short_frames: 'False'
    threshold: '8'
  states: {}
- name: satellites_bpsk_demodulator_0
  id: satellites_bpsk_demodulator
  parameters:
    baudrate: '400'
    differential: 'True'
    f_offset: '1500'
    manchester: 'False'
    samp_rate: samp_rate
  states: {}

connections:
- [audio_source_0, '0', satellites_bpsk_demodulator_0, '0']
- [satellites_ao40_fec_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_bpsk_demodulator_0, '0', satellites_ao40_fec_deframer_0, '0']

metadata:
  file_format: 1
