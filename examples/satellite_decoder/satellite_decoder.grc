options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: satellite_decoder
    output_language: python
    run_options: run
    title: Satellite decoder block example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:1,0
    samp_rate: samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: display_text_msg_0
  id: display_text_msg
  parameters:
    label: ' "QO-100"'
    messagekey: ''''''
    splitlength: '64'
  states: {}
- name: satellites_check_ao40_uncoded_crc_0
  id: satellites_check_ao40_uncoded_crc
  parameters: {}
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: file
    file: /home/schroer/gnuradiocomponents/gr-satellites/python/satyaml/QO-100.yml
    name: AO-40
    norad: ''
    samp_rate: samp_rate
  states: {}

connections:
- [audio_source_0, '0', satellites_satellite_decoder_0, '0']
- [satellites_check_ao40_uncoded_crc_0, ok, display_text_msg_0, text]
- [satellites_satellite_decoder_0, out, blocks_message_debug_0, print_pdu]
- [satellites_satellite_decoder_0, out, satellites_check_ao40_uncoded_crc_0, in]

metadata:
  file_format: 1
